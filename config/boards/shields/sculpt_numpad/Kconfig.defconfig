## config/boards/shields/sculpt_numpad/Kconfig.defconfig
```kconfig
if SHIELD_SCULPT_NUMPAD

config ZMK_KEYBOARD_NAME
	default "Sculpt Numpad"

endif
```
